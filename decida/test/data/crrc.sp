        * cr-rc
        vp p 0 sin 0.3 0.3 fosc 0 0 0
        vn n 0 sin 0.3 0.3 fosc 0 0 -180
        rcm1 p cm 10e3
        rcm2 n cm 10e3
        ccm  cm 0 100f
        r1p p  ip res
        c1p ip 0  cap
        r2p qp cm res
        c2p p  qp cap
        r1n n  in res
        c1n in 0  cap
        r2n qn cm res
        c2n n  qn cap
